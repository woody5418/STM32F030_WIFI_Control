# Keil uVision project STM32F030F4_Demo.uvprojx, settings and files
target STM32F030F4 (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F0308_Demo +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0XX,
  c misc: --c99
  c include: ..\STM32F030_FWLib\src;..\STM32F030_FWLib\inc;..\CORE;..\OBJ;..\USER;..\APPS;..\HARDWARE;..\SYSTEM;..\APPS;..\HARDWARE\USART1;..\HARDWARE\TIMER3;..\HARDWARE\LED;..\HARDWARE\TIMER2;..\HARDWARE\KEY;..\HARDWARE\ADC;..\HARDWARE\TIMER14
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group User
    ./: main.c stm32f0xx_it.c system_stm32f0xx.c includes.h
  group APPS
    ../APPS/: websocket.c esp8266.c espjson.c Airkiss.c
  group HARDWARE
    ../HARDWARE/USART1/: USART1.c
    ../HARDWARE/TIMER3/: timer3.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIMER2/: timer2.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/ADC/: ADC1.c
    ../HARDWARE/TIMER14/: timer14.c
  group SYSTEM
    ../SYSTEM/: delay.c
  group CORE
    ../CORE/: startup_stm32f030x8.s
  group STM32F0xx_FWLib
    ../STM32F030_FWLib/src/: stm32f0xx_adc.c stm32f0xx_crc.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c
  group ::CMSIS
    D:/Embedded/MDK/ARM/PACK/ARM/CMSIS/4.5.0/CMSIS/Lib/ARM/: arm_cortexM0l_math.lib
software components: CMSIS:CORE 5.0.1, CMSIS:DSP 1.5.1
